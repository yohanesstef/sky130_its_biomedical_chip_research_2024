v {xschem version=3.4.5 file_version=1.2
}
G {}
K {}
V {}
S {}
E {}
B 2 865 -1100 1665 -700 {flags=graph
y1=1.5e-05
y2=3.3e-05
ypos1=5.1e-06
ypos2=2.31e-05
divy=5
subdivy=1
unity=1
x1=0
x2=5e-07
divx=5
subdivx=1
xlabmag=1.0
ylabmag=1.0
node="\\"i(viref)@0.35; i(viref)%0\\"
\\"i(viref)@0.7; i(viref)%1\\"
\\"i(viref)@1.05; i(viref)%2\\"
\\"i(viref)@1.4; i(viref)%3\\"
\\"i(viref)@1.75; i(viref)%4\\"
\\"i(viref)@0.35; i(viref)%5\\"
\\"i(viref)@0.7; i(viref)%6\\"
\\"i(viref)@1.05; i(viref)%7\\"
\\"i(viref)@1.4; i(viref)%8\\"
\\"i(viref)@1.75; i(viref)%9\\""
color="7 8 9 10 11 12 13 14 15 16"
dataset=-1
unitx=1
logx=0
logy=0
digital=1}
B 2 865 -700 1665 -300 {flags=graph
y1=1.5e-11
y2=3.4e-05
ypos1=-2.45e-06
ypos2=2.855e-05
divy=5
subdivy=1
unity=1
x1=0
x2=5e-07
divx=5
subdivx=1
xlabmag=1.0
ylabmag=1.0
node="\\"i(vib)@0.35; i(vib)%0\\"
\\"i(vib)@0.7; i(vib)%1\\"
\\"i(vib)@1.05; i(vib)%2\\"
\\"i(vib)@1.4; i(vib)%3\\"
\\"i(vib)@1.75; i(vib)%4\\"
\\"i(vib)@0.35; i(vib)%5\\"
\\"i(vib)@0.7; i(vib)%6\\"
\\"i(vib)@1.05; i(vib)%7\\"
\\"i(vib)@1.4; i(vib)%8\\"
\\"i(vib)@1.75; i(vib)%9\\""
color="7 8 9 10 11 12 13 14 15 16"
dataset=-1
unitx=1
logx=0
logy=0
digital=1}
B 2 65 -700 865 -300 {flags=graph
y1=-0.044
y2=1.9
ypos1=0.7776519
ypos2=2.5321119
divy=5
subdivy=1
unity=1
x1=6.6789553e-09
x2=3.2667895e-07
divx=5
subdivx=1
xlabmag=1.0
ylabmag=1.0
node="\\"out@vcon=0; out%0\\"
\\"out@vcon=0.1; out%1\\"
\\"out@vcon=0.2; out%2\\"
\\"out@vcon=0.3; out%3\\"
\\"out@vcon=0.4; out%4\\"
\\"out@vcon=0.5; out%5\\"
\\"out@vcon=0.6; out%6\\"
\\"out@vcon=0.7; out%7\\"
\\"out@vcon=0.8; out%8\\"
\\"out@vcon=0.9; out%9\\"
\\"out@vcon=1; out%10\\"
\\"out@vcon=1.1; out%11\\"
\\"out@vcon=1.2; out%12\\"
\\"out@vcon=1.3; out%13\\"
\\"out@vcon=1.4; out%14\\"
\\"out@vcon=1.5; out%15\\"
\\"out@vcon=1.6; out%16\\"
\\"out@vcon=1.7; out%17\\"
\\"out@vcon=1.8; out%18\\""
color="7 8 9 10 11 12 13 14 15 16 17 18 19 20 21 4 5 6 7"
dataset=-1
unitx=1
logx=0
logy=0
digital=1
rainbow=1}
B 2 65 -1100 865 -700 {flags=graph
y1=1.6
y2=2
ypos1=1.4544447
ypos2=1.704033
divy=5
subdivy=1
unity=1
x1=6.6789553e-09
x2=3.2667895e-07
divx=5
subdivx=1
xlabmag=1.0
ylabmag=1.0
node="\\"vcon @0; vcon%0\\"
\\"vcon @0.1; vcon%1\\"
\\"vcon @0.2; vcon%2\\"
\\"vcon @0.3; vcon%3\\"
\\"vcon @0.4; vcon%4\\"
\\"vcon @0.5; vcon%5\\"
\\"vcon @0.6; vcon%6\\"
\\"vcon @0.7; vcon%7\\"
\\"vcon @0.8; vcon%8\\"
\\"vcon @0.9; vcon%9\\"
\\"vcon @1; vcon%10\\"
\\"vcon @1.1; vcon%11\\"
\\"vcon @1.2; vcon%12\\"
\\"vcon @1.3; vcon%13\\"
\\"vcon @1.4; vcon%14\\"
\\"vcon @1.5; vcon%15\\"
\\"vcon @1.6; vcon%16\\"
\\"vcon @1.7; vcon%17\\"
\\"vcon @1.8; vcon%18\\""
color="7 4 17 10 11 12 13 14 15 16 17 18 19 20 21 4 5 6 7"
dataset=-1
unitx=1
logx=0
logy=0
digital=0}
B 2 1665 -1100 2465 -700 {flags=graph
y1=1.5e-05
y2=3.3e-05
ypos1=5.1e-06
ypos2=2.31e-05
divy=5
subdivy=1
unity=1
x1=3.3053759e-07
x2=3.6671716e-07
divx=5
subdivx=1
xlabmag=1.0
ylabmag=1.0
node="\\"i(viref)vcon=0.0; i(viref)%0\\"
\\"i(viref)vcon=0.1; i(viref)%1\\"
\\"i(viref)vcon=0.2; i(viref)%2\\"
\\"i(viref)vcon=0.3; i(viref)%3\\"
\\"i(viref)vcon=0.4; i(viref)%4\\"
\\"i(viref)vcon=0.5; i(viref)%5\\"
\\"i(viref)vcon=0.6; i(viref)%6\\"
\\"i(viref)vcon=0.7; i(viref)%7\\"
\\"i(viref)vcon=0.8; i(viref)%8\\"
\\"i(viref)vcon=0.9; i(viref)%9\\"
\\"i(viref)vcon=1.0; i(viref)%10\\"
\\"i(viref)vcon=1.1; i(viref)%11\\"
\\"i(viref)vcon=1.2; i(viref)%12\\"
\\"i(viref)vcon=1.3; i(viref)%13\\"
\\"i(viref)vcon=1.4; i(viref)%14\\"
\\"i(viref)vcon=1.5; i(viref)%15\\"
\\"i(viref)vcon=1.6; i(viref)%16\\"
\\"i(viref)vcon=1.7; i(viref)%17\\"
\\"i(viref)vcon=1.8; i(viref)%18\\""
color="4 5 6 7 8 9 10 11 12 13 14 15 16 17 18 19 20 21 4"
dataset=-1
unitx=1
logx=0
logy=0
digital=1}
B 2 1665 -700 2465 -300 {flags=graph
y1=2e-11
y2=4.9e-05
ypos1=-2.45e-06
ypos2=2.855e-05
divy=5
subdivy=1
unity=1
x1=3.3053759e-07
x2=3.6671716e-07
divx=5
subdivx=1
xlabmag=1.0
ylabmag=1.0
node="\\"i(vib)@vcon=0.0; i(vib)%0\\"
\\"i(vib)@vcon=0.1; i(vib)%1\\"
\\"i(vib)@vcon=0.2; i(vib)%2\\"
\\"i(vib)@vcon=0.3; i(vib)%3\\"
\\"i(vib)@vcon=0.4; i(vib)%4\\"
\\"i(vib)@vcon=0.5; i(vib)%5\\"
\\"i(vib)@vcon=0.6; i(vib)%6\\"
\\"i(vib)@vcon=0.7; i(vib)%7\\"
\\"i(vib)@vcon=0.8; i(vib)%8\\"
\\"i(vib)@vcon=0.9; i(vib)%9\\"
\\"i(vib)@vcon=1.0; i(vib)%10\\"
\\"i(vib)@vcon=1.1; i(vib)%11\\"
\\"i(vib)@vcon=1.2; i(vib)%12\\"
\\"i(vib)@vcon=1.3; i(vib)%13\\"
\\"i(vib)@vcon=1.4; i(vib)%14\\"
\\"i(vib)@vcon=1.5; i(vib)%15\\"
\\"i(vib)@vcon=1.6; i(vib)%16\\"
\\"i(vib)@vcon=1.7; i(vib)%17\\"
\\"i(vib)@vcon=1.8; i(vib)%18\\""
color="4 5 6 7 8 9 10 11 12 13 14 15 16 17 18 19 20 21 8"
dataset=-1
unitx=1
logx=0
logy=0
digital=0}
B 2 125 -2000 925 -1600 {flags=graph
y1=-5.2e-05
y2=0.0002
ypos1=-0.4328
ypos2=1.5112
divy=5
subdivy=1
unity=1
x1=0
x2=5e-07
divx=5
subdivx=1
xlabmag=1.0
ylabmag=1.0
node="i(vi1)
i(vi2)"
color="7 4"
dataset=-1
unitx=1
logx=0
logy=0
digital=0
rainbow=1}
B 2 125 -1600 925 -1200 {flags=graph
y1=-5.2e-05
y2=0.0002
ypos1=-0.4328
ypos2=1.5112
divy=5
subdivy=1
unity=1
x1=0
x2=5e-07
divx=5
subdivx=1
xlabmag=1.0
ylabmag=1.0
node="i(vi3)
i(vi4)"
color="7 4"
dataset=-1
unitx=1
logx=0
logy=0
digital=0
rainbow=1}
B 2 1665 -1500 2465 -1100 {flags=graph
y1=1.5e-05
y2=3.3e-05
ypos1=1.86e-05
ypos2=3.66e-05
divy=5
subdivy=1
unity=1
x1=5e-08
x2=5.5e-07
divx=5
subdivx=1
xlabmag=1.0
ylabmag=1.0
node="\\"i(viref)@0.0; i(viref)%0\\"
\\"i(viref)@0.1; i(viref)%1\\"
\\"i(viref)@0.2; i(viref)%2\\"
\\"i(viref)@0.3; i(viref)%3\\"
\\"i(viref)@0.4; i(viref)%4\\"
\\"i(viref)@0.5; i(viref)%5\\"
\\"i(viref)@0.6; i(viref)%6\\"
\\"i(viref)@0.7; i(viref)%7\\"
\\"i(viref)@0.8; i(viref)%8\\"
\\"i(viref)@0.9; i(viref)%9\\"
\\"i(viref)@1.0; i(viref)%10\\"
\\"i(viref)@1.1; i(viref)%11\\"
\\"i(viref)@1.2; i(viref)%12\\"
\\"i(viref)@1.3; i(viref)%13\\"
\\"i(viref)@1.4; i(viref)%14\\"
\\"i(viref)@1.5; i(viref)%15\\"
\\"i(viref)@1.6; i(viref)%16\\"
\\"i(viref)@1.7; i(viref)%17\\"
\\"i(viref)@1.8; i(viref)%18\\""
color="7 8 9 10 11 12 13 14 15 16 17 18 19 20 21 4 5 20 21"
dataset=-1
unitx=1
logx=0
logy=0
digital=1}
B 2 1665 -1900 2465 -1500 {flags=graph
y1=1.5e-11
y2=3.4e-05
ypos1=-4e-06
ypos2=2.7e-05
divy=5
subdivy=1
unity=1
x1=5e-08
x2=5.5e-07
divx=5
subdivx=1
xlabmag=1.0
ylabmag=1.0
node="\\"i(vib)@0.0;i(vib)%0\\"
\\"i(vib)@0.1;i(vib)%1\\"
\\"i(vib)@0.2;i(vib)%2\\"
\\"i(vib)@0.3;i(vib)%3\\"
\\"i(vib)@0.4;i(vib)%4\\"
\\"i(vib)@0.5;i(vib)%5\\"
\\"i(vib)@0.6;i(vib)%6\\"
\\"i(vib)@0.7;i(vib)%7\\"
\\"i(vib)@0.8;i(vib)%8\\"
\\"i(vib)@0.9;i(vib)%9\\"
\\"i(vib)@1.0;i(vib)%10\\"
\\"i(vib)@1.1;i(vib)%11\\"
\\"i(vib)@1.2;i(vib)%12\\"
\\"i(vib)@1.3;i(vib)%13\\"
\\"i(vib)@1.4;i(vib)%14\\"
\\"i(vib)@1.5;i(vib)%15\\"
\\"i(vib)@1.6;i(vib)%16\\"
\\"i(vib)@1.7;i(vib)%17\\"
\\"i(vib)@1.8;i(vib)%18\\""
color="4 5 6 7 8 9 10 11 12 13 14 15 16 17 18 19 20 21 4"
dataset=-1
unitx=1
logx=0
logy=0
digital=1}
