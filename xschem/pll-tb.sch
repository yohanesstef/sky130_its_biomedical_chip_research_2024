v {xschem version=3.4.5 file_version=1.2
}
G {}
K {}
V {}
S {}
E {}
C {devices/title.sym} 160 -40 0 0 {name=l1 author="Stefan Schippers"}
C {vco.sym} 690 -240 0 0 {name=x1}
