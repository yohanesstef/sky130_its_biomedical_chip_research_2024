v {xschem version=3.4.5 file_version=1.2
}
G {}
K {}
V {}
S {}
E {}
C {devices/title.sym} 160 -40 0 0 {name=l1 author="Yohanes Stefanus"}
C {devices/ipin.sym} 260 -300 0 0 {name=p1 lab=VGND}
C {devices/ipin.sym} 260 -280 0 0 {name=p2 lab=VPWR}
C {devices/ipin.sym} 260 -260 0 0 {name=p3 lab=clk_i}
C {devices/opin.sym} 240 -240 0 0 {name=p4 lab=clk_o}
C {devices/opin.sym} 240 -220 0 0 {name=p5 lab=cycl_count_o[0:7]}
C {devices/ipin.sym} 260 -200 0 0 {name=p6 lab=div_i[0:7]}
C {devices/opin.sym} 240 -180 0 0 {name=p7 lab=div_ready_o}
C {devices/ipin.sym} 260 -160 0 0 {name=p8 lab=div_valid_i}
C {devices/ipin.sym} 260 -140 0 0 {name=p9 lab=en_i}
C {devices/ipin.sym} 260 -120 0 0 {name=p10 lab=rst_i}
C {devices/ipin.sym} 260 -100 0 0 {name=p11 lab=test_mode_en_i}
