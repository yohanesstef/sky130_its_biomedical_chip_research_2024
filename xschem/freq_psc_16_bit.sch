v {xschem version=3.4.5 file_version=1.2
}
G {}
K {}
V {}
S {}
E {}
C {devices/title.sym} 160 -40 0 0 {name=l1 author="Yohanes Stefanus"}
C {devices/ipin.sym} 200 -350 0 0 {name=p1 lab=VGND}
C {devices/ipin.sym} 200 -330 0 0 {name=p2 lab=VPWR}
C {devices/ipin.sym} 200 -310 0 0 {name=p3 lab=clk}
C {devices/opin.sym} 180 -290 0 0 {name=p4 lab=out}
C {devices/ipin.sym} 200 -270 0 0 {name=p5 lab=psc[0:15]}
C {devices/ipin.sym} 200 -250 0 0 {name=p6 lab=rst}
